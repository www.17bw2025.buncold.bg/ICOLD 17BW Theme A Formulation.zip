** ***************************************************************************
**   Written by : Femap
**   Version    : 2023.2.0
**   From Model : \\ricerca.lan\Archivio\Idroelettrico\RdS\2024\BW\FEMAP\Tsankov Kamak Dam Foundation_v01.modfem
**   Date       : Thu May 30 10:19:40 2024
** ***************************************************************************
**
*HEADING
Tsankov Kamak
*NODE, NSET=GLOBAL
       1,       -700.,-5.68434E-14,       288.5
       2,       -700.,-5.68434E-14,   351.35714
       3,       -700.,-5.68434E-14,    403.7381
       4,       -700.,-5.68434E-14,   445.64286
       5,       -700.,-5.68434E-14,   477.07143
       6,       -700.,-5.68434E-14,   498.02381
       7,       -700.,-5.68434E-14,       508.5
       8,       -700.,-5.68434E-14,   517.53571
       9,       -700.,-5.68434E-14,   526.57143
      10,       -700.,-5.68434E-14,   535.60714
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*ELEMENT, TYPE=C3D8, ELSET=Foundation
      1,     37,   2018,   1983,      2,     36,   2017,   1982,      1
      2,     38,   2019,   1984,      3,     37,   2018,   1983,      2
      3,     39,   2020,   1985,      4,     38,   2019,   1984,      3
      4,     40,   2021,   1986,      5,     39,   2020,   1985,      4
      5,     41,   2022,   1987,      6,     40,   2021,   1986,      5
      6,     42,   2023,   1988,      7,     41,   2022,   1987,      6
      7,   2023,   2024,     43,     42,   1988,   1989,      8,      7
      8,   2024,   2025,     44,     43,   1989,   1990,      9,      8
      9,   2025,   2026,     45,     44,   1990,   1991,     10,      9
     10,   2026,   2027,     46,     45,   1991,   1992,     11,     10
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*ELEMENT, TYPE=C3D8, ELSET=Dam
  26393,  28604,  28609,  29706,  29700,  28608,  28613,  29673,  29647
  26394,  28610,  28604,  29700,  29707,  28614,  28608,  29647,  29674
  26395,  28601,  28605,  29724,  29714,  28604,  28609,  29706,  29700
  26396,  28606,  28601,  29714,  29725,  28610,  28604,  29700,  29707
  26397,  28545,  28602,  29747,  29735,  28601,  28605,  29724,  29714
  26398,  28603,  28545,  29735,  29748,  28606,  28601,  29714,  29725
  26399,  28608,  28613,  29673,  29647,  28628,  28630,  29708,  29701
  26400,  28614,  28608,  29647,  29674,  28631,  28628,  29701,  29709
  26401,  28609,  28620,  29739,  29706,  28613,  28626,  29722,  29673
  26402,  28621,  28610,  29707,  29740,  28627,  28614,  29674,  29723
  26403,  28605,  28617,  29755,  29724,  28609,  28620,  29739,  29706
  26404,  28618,  28606,  29725,  29756,  28621,  28610,  29707,  29740
  26405,  28602,  28615,  29811,  29747,  28605,  28617,  29755,  29724
  26406,  28616,  28603,  29748,  29812,  28618,  28606,  29725,  29756
  26407,  28607,  28611,  29872,  29860,  28545,  28602,  29747,  29735
  26408,  28612,  28607,  29860,  29873,  28603,  28545,  29735,  29748
  26409,  28627,  28614,  29674,  29723,  28725,  28631,  29709,  29742
  26410,  28613,  28626,  29722,  29673,  28630,  28724,  29741,  29708
*ELEMENT, TYPE=C3D8, ELSET=Foundation
  26411,  29607,  28323,  28704,  30348,  29606,  28322,  28703,  30347
  26412,  29608,  28324,  28705,  30349,  29607,  28323,  28704,  30348
  26413,  29609,  28325,  28706,  30350,  29608,  28324,  28705,  30349
  26414,  29610,  28326,  28707,  30351,  29609,  28325,  28706,  30350
  26415,  29611,  28327,  28708,  30352,  29610,  28326,  28707,  30351
  26416,  29612,  28328,  28709,  30353,  29611,  28327,  28708,  30352
  26417,  29613,  28329,  28710,  30354,  29612,  28328,  28709,  30353
  26418,  29614,  28330,  28711,  30355,  29613,  28329,  28710,  30354
  26419,  29615,  28331,  28712,  30356,  29614,  28330,  28711,  30355
  26420,  29616,  28332,  28713,  30357,  29615,  28331,  28712,  30356
  26421,  29617,  28333,  28714,  30358,  29616,  28332,  28713,  30357
  26422,  29618,  28334,  28715,  30359,  29617,  28333,  28714,  30358
  26423,  29619,  28335,  28716,  30360,  29618,  28334,  28715,  30359
  26424,  29620,  28336,  28717,  30361,  29619,  28335,  28716,  30360
  26425,  29621,  28337,  28718,  30362,  29620,  28336,  28717,  30361
  26426,  29622,  28338,  28719,  30363,  29621,  28337,  28718,  30362
  26427,  29623,  28339,  28720,  30364,  29622,  28338,  28719,  30363
  26428,  29624,  28340,  28721,  30365,  29623,  28339,  28720,  30364
  26429,  29625,  28341,  28722,  30366,  29624,  28340,  28721,  30365
  26430,  29626,  28342,  28723,  30367,  29625,  28341,  28722,  30366
*ELEMENT, TYPE=C3D8, ELSET=Dam
  26431,  28628,  28630,  29708,  29701,  28726,  28735,  29730,  29721
  26432,  28631,  28628,  29701,  29709,  28736,  28726,  29721,  29731
*ELEMENT, TYPE=C3D8, ELSET=Foundation
  26433,  30497,  27321,  27931,  31621,  30518,  27342,  27932,  31622
  26434,  30518,  27342,  27932,  31622,  30539,  27363,  27933,  31623
  26435,  30539,  27363,  27933,  31623,  30560,  27384,  27934,  31624
  26436,  30560,  27384,  27934,  31624,  30581,  27405,  27935,  31625
  26437,  30581,  27405,  27935,  31625,  30602,  27426,  27936,  31626
  26438,  30602,  27426,  27936,  31626,  30623,  27447,  27937,  31627
*ELEMENT, TYPE=C3D8, ELSET=Dam
  26439,  28611,  28624,  29909,  29872,  28602,  28615,  29811,  29747
  26440,  28625,  28612,  29873,  29910,  28616,  28603,  29748,  29812
*ELEMENT, TYPE=C3D8, ELSET=Foundation
  26441,  30623,  27447,  27937,  31627,  30644,  27468,  27938,  31628
  26442,  30644,  27468,  27938,  31628,  30665,  27489,  27939,  31629
  26443,  30665,  27489,  27939,  31629,  30686,  27510,  27940,  31630
  26444,  30686,  27510,  27940,  31630,  30707,  27531,  27941,  31631
  26445,  30707,  27531,  27941,  31631,  30728,  27552,  27942,  31632
  26446,  30728,  27552,  27942,  31632,  30749,  27573,  27943,  31633
  26447,  30893,  28683,  27945,  29680,  30892,  28682,  27944,  29679
  26448,  30894,  28684,  27946,  29681,  30893,  28683,  27945,  29680
  26449,  30895,  28685,  27947,  29682,  30894,  28684,  27946,  29681
  26450,  30896,  28686,  27948,  29683,  30895,  28685,  27947,  29682
  26451,  30897,  28687,  27949,  29684,  30896,  28686,  27948,  29683
  26452,  30898,  28688,  27950,  29685,  30897,  28687,  27949,  29684
  26453,  30899,  28689,  27951,  29686,  30898,  28688,  27950,  29685
  26454,  30900,  28690,  27952,  29687,  30899,  28689,  27951,  29686
  26455,  30901,  28691,  27953,  29688,  30900,  28690,  27952,  29687
  26456,  30902,  28692,  27954,  29689,  30901,  28691,  27953,  29688
  26457,  30903,  28693,  27955,  29690,  30902,  28692,  27954,  29689
  26458,  30904,  28694,  27956,  29691,  30903,  28693,  27955,  29690
  26459,  30905,  28695,  27957,  29692,  30904,  28694,  27956,  29691
  26460,  30906,  28696,  27958,  29693,  30905,  28695,  27957,  29692
  26461,  30907,  28697,  27959,  29694,  30906,  28696,  27958,  29693
  26462,  30908,  28698,  27960,  29695,  30907,  28697,  27959,  29694
  26463,  30909,  28699,  27961,  29696,  30908,  28698,  27960,  29695
  26464,  30910,  28700,  27962,  29697,  30909,  28699,  27961,  29696
  26465,  30911,  28701,  27963,  29698,  30910,  28700,  27962,  29697
  26466,  30912,  28702,  27964,  29699,  30911,  28701,  27963,  29698
*ELEMENT, TYPE=C3D8, ELSET=Dam
  26467,  28620,  28727,  29861,  29739,  28626,  28733,  29809,  29722
  26468,  28728,  28621,  29740,  29862,  28734,  28627,  29723,  29810
  26469,  28725,  28631,  29709,  29742,  28756,  28736,  29731,  29779
  26470,  28630,  28724,  29741,  29708,  28735,  28755,  29778,  29730
  26471,  28617,  28680,  29878,  29755,  28620,  28727,  29861,  29739
  26472,  28681,  28618,  29756,  29879,  28728,  28621,  29740,  29862
  26473,  28615,  28657,  29905,  29811,  28617,  28680,  29878,  29755
  26474,  28658,  28616,  29812,  29906,  28681,  28618,  29756,  29879
  26475,  28619,  28622,  29980,  29972,  28607,  28611,  29872,  29860
  26476,  28623,  28619,  29972,  29981,  28612,  28607,  29860,  29873
*ELEMENT, TYPE=C3D8, ELSET=Foundation
  26477,  30098,  28635,  28483,  29789,  30097,  28634,  28482,  29788
  26478,  30099,  28636,  28484,  29790,  30098,  28635,  28483,  29789
  26479,  30100,  28637,  28485,  29791,  30099,  28636,  28484,  29790
  26480,  30101,  28638,  28486,  29792,  30100,  28637,  28485,  29791
  26481,  30102,  28639,  28487,  29793,  30101,  28638,  28486,  29792
  26482,  30103,  28640,  28488,  29794,  30102,  28639,  28487,  29793
*ELEMENT, TYPE=C3D8, ELSET=Dam
  26483,  28734,  28627,  29723,  29810,  28761,  28725,  29742,  29864
  26484,  28626,  28733,  29809,  29722,  28724,  28760,  29863,  29741
  26485,  28726,  28735,  29730,  29721,  28757,  28762,  29753,  29738
  26486,  28736,  28726,  29721,  29731,  28763,  28757,  29738,  29754
*ELEMENT, TYPE=C3D8, ELSET=Foundation
  26487,  30104,  28641,  28489,  29795,  30103,  28640,  28488,  29794
  26488,  30105,  28642,  28490,  29796,  30104,  28641,  28489,  29795
  26489,  30106,  28643,  28491,  29797,  30105,  28642,  28490,  29796
  26490,  30107,  28644,  28492,  29798,  30106,  28643,  28491,  29797
  26491,  30108,  28645,  28493,  29799,  30107,  28644,  28492,  29798
  26492,  30109,  28646,  28494,  29800,  30108,  28645,  28493,  29799
  26493,  30110,  28647,  28495,  29801,  30109,  28646,  28494,  29800
  26494,  30111,  28648,  28496,  29802,  30110,  28647,  28495,  29801
  26495,  30112,  28649,  28497,  29803,  30111,  28648,  28496,  29802
  26496,  30113,  28650,  28498,  29804,  30112,  28649,  28497,  29803
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*ELEMENT, TYPE=C3D8, ELSET=Dam
  26561,  28622,  28655,  30073,  29980,  28611,  28624,  29909,  29872
  26562,  28656,  28623,  29981,  30074,  28625,  28612,  29873,  29910
  26563,  28624,  28731,  30069,  29909,  28615,  28657,  29905,  29811
  26564,  28732,  28625,  29910,  30070,  28658,  28616,  29812,  29906
  26565,  28735,  28755,  29778,  29730,  28762,  28819,  29836,  29753
  26566,  28756,  28736,  29731,  29779,  28820,  28763,  29754,  29837
  26567,  28761,  28725,  29742,  29864,  28824,  28756,  29779,  29883
  26568,  28724,  28760,  29863,  29741,  28755,  28823,  29882,  29778
*ELEMENT, TYPE=C3D8, ELSET=Foundation
  26569,  31994,  28281,  27638,  30935,  31993,  28280,  27637,  30934
  26570,  31995,  28282,  27639,  30936,  31994,  28281,  27638,  30935
  26571,  31996,  28283,  27640,  30937,  31995,  28282,  27639,  30936
  26572,  31997,  28284,  27641,  30938,  31996,  28283,  27640,  30937
  26573,  31998,  28285,  27642,  30939,  31997,  28284,  27641,  30938
  26574,  31999,  28286,  27643,  30940,  31998,  28285,  27642,  30939
  26575,  32000,  28287,  27644,  30941,  31999,  28286,  27643,  30940
  26576,  32001,  28288,  27645,  30942,  32000,  28287,  27644,  30941
  26577,  32002,  28289,  27646,  30943,  32001,  28288,  27645,  30942
  26578,  32003,  28290,  27647,  30944,  32002,  28289,  27646,  30943
  26579,  32004,  28291,  27648,  30945,  32003,  28290,  27647,  30944
  26580,  32005,  28292,  27649,  30946,  32004,  28291,  27648,  30945
  26581,  32006,  28293,  27650,  30947,  32005,  28292,  27649,  30946
  26582,  32007,  28294,  27651,  30948,  32006,  28293,  27650,  30947
  26583,  32008,  28295,  27652,  30949,  32007,  28294,  27651,  30948
  26584,  32009,  28296,  27653,  30950,  32008,  28295,  27652,  30949
  26585,  32010,  28297,  27654,  30951,  32009,  28296,  27653,  30950
  26586,  32011,  28298,  27655,  30952,  32010,  28297,  27654,  30951
  26587,  32012,  28299,  27656,  30953,  32011,  28298,  27655,  30952
  26588,  32013,  28300,  27657,  30954,  32012,  28299,  27656,  30953
*ELEMENT, TYPE=C3D8, ELSET=Dam
  26589,  28629,  28632,  30120,  30090,  28619,  28622,  29980,  29972
  26590,  28633,  28629,  30090,  30121,  28623,  28619,  29972,  29981
  26591,  28727,  28812,  29986,  29861,  28733,  28816,  29957,  29809
  26592,  28813,  28728,  29862,  29987,  28817,  28734,  29810,  29958
  26593,  28757,  28762,  29753,  29738,  28850,  28954,  29876,  29867
  26594,  28763,  28757,  29738,  29754,  28955,  28850,  29867,  29877
  26595,  28680,  28787,  30065,  29878,  28727,  28812,  29986,  29861
  26596,  28788,  28681,  29879,  30066,  28813,  28728,  29862,  29987
  26597,  28657,  28758,  30079,  29905,  28680,  28787,  30065,  29878
  26598,  28759,  28658,  29906,  30080,  28788,  28681,  29879,  30066
  26599,  28632,  28729,  30165,  30120,  28622,  28655,  30073,  29980
  26600,  28730,  28633,  30121,  30166,  28656,  28623,  29981,  30074
  26601,  28655,  28751,  30157,  30073,  28624,  28731,  30069,  29909
  26602,  28752,  28656,  30074,  30158,  28732,  28625,  29910,  30070
  26603,  28733,  28816,  29957,  29809,  28760,  28895,  29989,  29863
  26604,  28817,  28734,  29810,  29958,  28896,  28761,  29864,  29990
  26605,  28824,  28756,  29779,  29883,  28957,  28820,  29837,  29912
  26606,  28755,  28823,  29882,  29778,  28819,  28956,  29911,  29836
  26607,  28762,  28819,  29836,  29753,  28954,  29095,  29934,  29876
  26608,  28820,  28763,  29754,  29837,  29096,  28955,  29877,  29935
  26609,  28731,  28814,  30174,  30069,  28657,  28758,  30079,  29905
  26610,  28815,  28732,  30070,  30175,  28759,  28658,  29906,  30080
  26611,  28760,  28895,  29989,  29863,  28823,  29097,  30067,  29882
  26612,  28896,  28761,  29864,  29990,  29098,  28824,  29883,  30068
  26613,  28750,  28753,  30272,  30225,  28629,  28632,  30120,  30090
  26614,  28754,  28750,  30225,  30273,  28633,  28629,  30090,  30121
  26615,  28729,  28764,  30220,  30165,  28655,  28751,  30157,  30073
  26616,  28765,  28730,  30166,  30221,  28752,  28656,  30074,  30158
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** Femap Group 1 : Dam
*NSET, NSET=Dam, GENERATE
28545,28545,1
28601,28633,1
28655,28658,1
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** Femap Group 1 : Dam
*ELSET, ELSET=Dam
26393,26394,26395,26396,26397,26398,26399,26400,26401,26402
26403,26404,26405,26406,26407,26408,26409,26410,26431,26432
26439,26440,26467,26468,26469,26470,26471,26472,26473,26474
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** Femap Group 2 : Foundation
*NSET, NSET=Foundation, GENERATE
1,28544,1
28546,28600,1
28634,28654,1
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** Femap Group 2 : Foundation
*ELSET, ELSET=Foundation, GENERATE
1,26392,1
26411,26430,1
26433,26438,1
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** Femap Group 3 : Node boundary X dir
*NSET, NSET=Node_boundary_X_dir, GENERATE
1,1981,1
94173,96153,1
** Femap Group 4 : Node boundary Y dir
*NSET, NSET=Node_boundary_Y_dir
1,2,3,4,5,6,7,8,9,10
11,12,13,14,15,16,17,18,19,20
21,22,23,24,25,26,27,28,29,30
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** Femap Group 5 : Node boundary Z dir
*NSET, NSET=Node_boundary_Z_dir
1,36,71,106,141,176,211,260,303,347
384,412,435,456,477,498,519,540,561,582
603,624,645,666,687,708,729,750,771,792
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*ELSET, ELSET=OUT_CONT, GENERATE
1,86672,1
** Femap Property 1 : Dam
*SOLID SECTION, ELSET=Dam, MATERIAL=Dam
** Femap Property 2 : Foundation
*ORIENTATION, NAME=GLOBAL_0, DEFINITION=COORDINATES, SYSTEM=RECTANGULAR
        1.,        0.,        0.,        0.,        1.,        0.
*SOLID SECTION, ELSET=Foundation, MATERIAL=Foundation, ORIENTATION=GLOBAL_0
** Femap Material 1 : Dam
*MATERIAL, NAME=Dam
*ELASTIC, TYPE=ISOTROPIC
        0.,        0.,        0.
** Femap Material 2 : Shell
*MATERIAL, NAME=Shell
*ELASTIC, TYPE=ISOTROPIC
        0.,        0.,        0.
** Femap Material 3 : Foundation
*MATERIAL, NAME=Foundation
*ELASTIC, TYPE=ISOTROPIC
        0.,        0.,        0.
** Load Step 1 -------------------------------------------------------
*STEP, INC=100
Untitled
*STATIC

*OUTPUT,FIELD
*NODE OUTPUT
    U,
*NODE PRINT, FREQUENCY=1
    U,
*FILE FORMAT, ASCII
*NODE FILE, FREQUENCY=1
    U,
*OUTPUT,FIELD
*NODE OUTPUT
   CF,
*NODE FILE, FREQUENCY=1
   CF,
*OUTPUT,FIELD
*NODE OUTPUT
   RF,
*NODE FILE, FREQUENCY=1
   RF,
*OUTPUT,FIELD
*ELEMENT OUTPUT, ELSET=OUT_CONT, POSITION=CENTROIDAL
    S,
 SINV,
*ELEMENT OUTPUT, ELSET=OUT_CONT,	POSITION=NODES
    S,
 SINV,
*EL PRINT, ELSET=OUT_CONT,FREQUENCY=1, POSITION=CENTROIDAL
    S,
 SINV,
*EL PRINT, ELSET=OUT_CONT,FREQUENCY=1,	POSITION=NODES
    S,
 SINV,
*EL FILE, ELSET=OUT_CONT,FREQUENCY=1, POSITION=CENTROIDAL
    S,
 SINV,
*EL FILE, ELSET=OUT_CONT,FREQUENCY=1,	POSITION=NODES
    S,
 SINV,
*OUTPUT,FIELD
*ELEMENT OUTPUT, ELSET=OUT_CONT, POSITION=CENTROIDAL
*ELEMENT OUTPUT, ELSET=OUT_CONT,	POSITION=NODES
*EL PRINT, ELSET=OUT_CONT,FREQUENCY=1, POSITION=CENTROIDAL
*EL PRINT, ELSET=OUT_CONT,FREQUENCY=1,	POSITION=NODES
*EL FILE, ELSET=OUT_CONT,FREQUENCY=1, POSITION=CENTROIDAL
*EL FILE, ELSET=OUT_CONT,FREQUENCY=1,	POSITION=NODES
*END STEP
