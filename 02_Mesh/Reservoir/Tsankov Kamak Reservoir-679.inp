** ***************************************************************************
**   Written by : Femap
**   Version    : 2023.2.0
**   From Model : \\ricerca.lan\Archivio\Idroelettrico\RdS\2024\BW\FEMAP\Reservoir\Tsankov Kamak Reservoir-679.modfem
**   Date       : Thu May 30 10:30:53 2024
** ***************************************************************************
**
*HEADING
Tsankov Kamak
*NODE, NSET=GLOBAL
  200000,    -320.204,      496.76,      679.01
  200001,    -319.735,     496.238,        675.
  200002,    -319.275,     495.724,        671.
  200003,    -318.824,      495.22,        667.
  200004,     -323.55,      490.75,        663.
  200005,    -328.277,      486.28,        659.
  200006,     -332.54,     482.291,       655.4
  200007,    -336.217,     478.813,     650.933
  200008,     -339.43,     475.817,     646.867
  200009,    -342.644,      472.82,       642.8
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*ELEMENT, TYPE=C3D8, ELSET=Water
 200000, 200001, 200089, 200088, 200000, 202000, 202088, 202087, 201999
 200001, 202000, 202088, 202087, 201999, 203999, 204087, 204086, 203998
 200002, 200089, 200093, 200092, 200088, 202088, 202092, 202091, 202087
 200003, 202088, 202092, 202091, 202087, 204087, 204091, 204090, 204086
 200004, 203999, 204087, 204086, 203998, 205998, 206086, 206085, 205997
 200005, 204087, 204091, 204090, 204086, 206086, 206090, 206089, 206085
 200006, 200093, 200097, 200096, 200092, 202092, 202096, 202095, 202091
 200007, 202092, 202096, 202095, 202091, 204091, 204095, 204094, 204090
 200008, 204091, 204095, 204094, 204090, 206090, 206094, 206093, 206089
 200009, 205998, 206086, 206085, 205997, 207997, 208085, 208084, 207996
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** Femap Group 1 : Reservoir
*ELSET, ELSET=Reservoir, GENERATE
200000,219099,1
** Femap Group 2 : Node free field
*NSET, NSET=Node_free_field
200000,200074,200088,200092,200096,200101,200106,200112,200118,200125
200134,200143,200152,200162,200172,200183,200194,200213,200233,200246
200259,200272,200285,200300,200318,200337,200358,200380,200404,200427
200450,200473,200496,200520,200544,200568,200593,200618,200641,200658
200686,200714,200743,200772,200802,200832,200862,200892,200922,200952
200982,201012,201042,201043,201073,201103,201133,201163,201193,201223
201253,201283,201312,201341,201369,201397,201415,201437,201462,201487
201511,201535,201559,201582,201605,201628,201651,201673,201696,201716
201735,201753,201770,201787,201803,201819,201834,201857,201875,201889
201901,201913,201924,201934,201944,201953,201962,201969,201976,201982
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*ELSET, ELSET=OUT_CONT, GENERATE
200000,219099,1
** Femap Property 1 : Water
*ORIENTATION, NAME=GLOBAL_0, DEFINITION=COORDINATES, SYSTEM=RECTANGULAR
        1.,        0.,        0.,        0.,        1.,        0.
*SOLID SECTION, ELSET=Water, MATERIAL=Water, ORIENTATION=GLOBAL_0
** Femap Material 1 : Water
*MATERIAL, NAME=Water
*ELASTIC, TYPE=ISOTROPIC
        0.,      0.29,        0.
** Femap Region 1 : Bacino-Diga
*SURFACE, NAME=Bacino-Diga, TYPE=ELEMENT
 200000, S1
 200002, S1
 200006, S1
 200012, S1
 200020, S1
 200030, S1
 200042, S1
 200056, S1
 200080, S1
 200090, S1
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** Femap Region 2 : Bacino-Laterale
*SURFACE, NAME=Bacino-Laterale, TYPE=ELEMENT
 200000, S6
 200001, S6
 200004, S6
 200009, S6
 200016, S6
 200025, S6
 200036, S6
 200049, S6
 200064, S6
 200072, S6
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** Femap Region 3 : Bacino-Monte
*SURFACE, NAME=Bacino-Monte, TYPE=ELEMENT
 200072, S2
 200073, S2
 200074, S2
 200075, S2
 200076, S2
 200077, S2
 200078, S2
 200079, S2
 200089, S2
 200099, S2
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** Load Step 1 -------------------------------------------------------
*STEP, INC=100
Untitled
*STATIC

*EL PRINT, FREQUENCY = 0
*NODE PRINT, FREQUENCY = 0
*FILE FORMAT, ASCII, ZERO INCREMENT
*NODE FILE
    U,
*NODE FILE
   RF,
*EL FILE, ELSET=OUT_CONT, POSITION=CENTROIDAL
    S,
 SINV,
*EL FILE, ELSET=OUT_CONT, POSITION=CENTROIDAL
*EL FILE, ELSET=OUT_CONT, POSITION=CENTROIDAL
    E,
   PE,
   IE,
*END STEP
